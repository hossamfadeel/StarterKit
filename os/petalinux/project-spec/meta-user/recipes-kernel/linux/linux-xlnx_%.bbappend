SRC_URI += "file://user_2018-07-09-13-08-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

